# Keil uVision project NoiApSuat3.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NoiApSuat3
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c include: ..\NoiApSuat3;.\A_USER;.\BLDC;.\Delay;.\CAN;.\GPIO;.\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./A_USER/: main.c main.h startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h system_timetick.c system_timetick.h
  group Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
  group Delay
    ./Delay/: Delay.c Delay.h
  group CAN
    ./CAN/: CAN.c CAN.h
  group BLDC
    ./BLDC/: BLDC.c BLDC.h
  group GPIO
    ./GPIO/: KB_GPIO.c KB_GPIO.h
software components: CMSIS:CORE 4.3.0
